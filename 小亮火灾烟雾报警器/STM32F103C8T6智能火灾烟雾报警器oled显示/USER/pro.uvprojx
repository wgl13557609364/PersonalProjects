# Keil uVision project pro.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3\CoreSupport;..\DEVICE_LIB\inc;..\SYSTEM;..\USER;..\HARDWARE\ADC;..\HARDWARE\Buzzer;..\HARDWARE\DS18B20;..\HARDWARE\LED;..\HARDWARE\OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group COMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/: system_stm32f10x.c system_stm32f10x.h stm32f10x.h
  group DEVICE_LIB
    ../DEVICE_LIB/src/: stm32f10x_rcc.c misc.c stm32f10x_adc.c stm32f10x_gpio.c
  group HARDWARE
    ../HARDWARE/ADC/: bsp_adc.c
    ../HARDWARE/Buzzer/: buzzer.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
  group USER
    ./: main.c stm32f10x_it.c delay.c
